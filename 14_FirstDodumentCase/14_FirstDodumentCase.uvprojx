# Keil uVision project 14_FirstDodumentCase.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCompiler_506_b960)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 01_LED_Register +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Driver\I2C;.\Driver\KEY;.\Driver\LED;.\Driver\USART;.\Inf\W24C02;.\Start;.\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start
    ./Start/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group User
    ./User/: Delay.c main.c
  group Driver\I2C
    ./Driver/I2C/: Driver_I2C2.c
  group Driver\KEY
    ./Driver/KEY/: Driver_Key.c
  group Driver\USART
    ./Driver/USART/: Driver_USART.c
  group Driver\LED
    ./Driver/LED/: Driver_LED.c
  group Inf\W24C02
    ./Inf/W24C02/: Inf_W24C02.c
