# Keil uVision project 41_FSMC_SRAM_Register.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCompiler_506_b960)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 01_LED_Register +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Start;.\User;.\Driver\LED;.\Driver\USART;.\Driver\SYSTICK;.\Driver\TIMER;.\Driver\DMA;.\Driver\ADC;.\Driver\SPI;.\Inf\W25Q32;.\Driver\FSMC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start
    ./Start/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group User
    ./User/: main.c delay.c
  group Driver
    ./Driver/LED/: Driver_LED .c
    ./Driver/USART/: Driver_USART.c
    ./Driver/DMA/: Driver_DMA.c
    ./Driver/ADC/: Driver_ADC.c
    ./Driver/SPI/: Driver_SPI.c
    ./Driver/FSMC/: Driver_FSMC.c
  group Inf
    ./Inf/W25Q32/: Inf_W25Q32.c
